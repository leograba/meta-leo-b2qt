IMAGE_INSTALL_append = " imx-gst1.0-plugin e2fsprogs e2fsprogs-resize2fs"
